# Keil uVision project BT_Overview.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BT_Overview
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group C_File
    ./: main.c Setup_Port_S32K144.c BT01_BitMask.c BT02_GPIOPolling.c BT03_GPIOInterrupt.c BT04_SysTickTimer.c BT05_Clock.c BT06_Timer.c
  group H_File
    ./: Setup_Port_S32K144.h BT01_BitMask.h BT02_GPIOPolling.h BT03_GPIOInterrupt.h BT04_SysTickTimer.h BT05_Clock.h BT06_Timer.h
  group H_Source
    ./: GPIO_Type.h PCC_Type.h PORT_Type.h INTERUPT_TYPE.h SYSTICK_Type.h LPIT_TYPE.h LPSPI_TYPE.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
